FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SPLASH_IMAGES = "file://pionix-logo-splash.png;outsuffix=default"
