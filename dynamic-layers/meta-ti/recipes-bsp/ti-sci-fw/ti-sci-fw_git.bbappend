SYSFW_PREFIX:phyboard-lyra-am62xx-k3r5 = "fs"
