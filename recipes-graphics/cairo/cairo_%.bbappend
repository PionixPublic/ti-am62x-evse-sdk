PACKAGECONFIG:remove = "x11 opengl"
